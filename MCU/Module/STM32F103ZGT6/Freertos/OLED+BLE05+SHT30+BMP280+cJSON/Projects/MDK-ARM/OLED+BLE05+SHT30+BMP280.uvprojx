# Keil uVision project OLED+BLE05+SHT30+BMP280.uvprojx, settings and files
target BSS_Hub (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: OLED+BLE05 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,DEBUG_MODE=1
  c include: ..\..\App\inc;..\..\Bsp\inc;..\..\Components\Algorithm\inc;..\..\Components\Protocol\inc;..\..\Config;..\..\Middlewares\cJSON;..\..\Middlewares\FreeRTOS\include;..\..\Middlewares\FreeRTOS\portable\RVDS\ARM_CM3;..\..\System\Lib\inc;..\..\System\Startup
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group APP/src
    ../../App/src/: freertos_tasks.c main.c stm32f10x_it.c
  group BSP/src
    ../../Bsp/src/: bsp_ble.c bsp_font.c bsp_led.c bsp_oled.c bsp_photo.c bsp_timer.c bsp_usart_it.c bsp_i2c.c bsp_sht30.c bsp_bmp280.c
  group Config
    ../../Config/: user_config.c user_config.h FreeRTOSConfig.h
  group Middlewares/FreeRTOS/portable/MemMang
    ../../Middlewares/FreeRTOS/portable/MemMang/: heap_4.c
  group Middlewares/FreeRTOS/portable/RVDS/ARM_CM3
    ../../Middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/FreeRTOS/source
    ../../Middlewares/FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group System/Lib/src
    ../../System/Lib/src/: delay.c sys.c
  group System/Startup
    ../../System/Startup/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
